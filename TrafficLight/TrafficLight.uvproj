# Keil uVision project TrafficLight.uvproj, settings and files
target TrafficLight (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TrafficLight
  c flags: Optim=1
  c include: ..;..\..\..;..\..\Examples
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: TrafficMain.c startup.s
